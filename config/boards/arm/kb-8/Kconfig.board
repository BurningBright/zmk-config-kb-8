## config/boards/arm/kb-8/Kconfig.board
```kconfig
# Copyright (c) 2023 burningbright
# SPDX-License-Identifier: MIT

config BOARD_KB_8
    bool "kb-8"
    depends on SOC_NRF52840_QIAA
```
